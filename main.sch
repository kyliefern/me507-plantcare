File: main.sch (EAGLE design)
At the start: 0 parts

Commit message: Add files via upload
Parts:
- added U1: ATMEGA328P-AU, Downloads:ATMEGA328P-AU
- added U2: DRV8833PWPR, Downloads:DRV8833PWPR
